options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: de_emphasis_tau
  id: variable_qtgui_check_box
  parameters:
    'false': '50e-6'
    label: 75 us de-emphasis
    'true': '75e-6'
    type: real
    value: '75e-6'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: pll_max_freq
  id: variable
  parameters:
    value: 19050*2*3.14159/if_samp_rate
  states: {}
- name: pll_min_freq
  id: variable
  parameters:
    value: 18950*2*3.14159/if_samp_rate
  states: {}
- name: radio_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '106200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: stereo_gain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: Enable stereo
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_samp_rate
    tau: de_emphasis_tau
  states: {}
- name: analog_fm_deemph_1
  id: analog_fm_deemph
  parameters:
    samp_rate: if_samp_rate
    tau: de_emphasis_tau
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '90000'
    audio_stop: '94000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '0'
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: pll_max_freq
    min_freq: pll_min_freq
    w: '0.0002'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: Stereo radio signal out
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '21000'
    low_cutoff_freq: '17000'
    samp_rate: if_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '41000'
    low_cutoff_freq: '35000'
    samp_rate: if_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '3'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: fm_demod_test.wav
    repeat: 'True'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: if_samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: stereo_gain
    samp_rate: if_samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Left
    label2: Right
    nconnections: '2'
    size: '2048'
    srate: '48000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '3'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '8'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: radio_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_fm_deemph_1, '0', rational_resampler_xxx_0_0_0_0, '0']
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', analog_pll_refout_cc_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0_0_0, '0', blocks_sub_xx_0, '1']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_float_to_complex_1, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', audio_sink_0_0, '1']
- [rational_resampler_xxx_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
