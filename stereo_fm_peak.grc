options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: if_samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: pll_max_freq
  id: variable
  parameters:
    value: 19050*2*3.14159/if_samp_rate
  states: {}
- name: pll_min_freq
  id: variable
  parameters:
    value: 18950*2*3.14159/if_samp_rate
  states: {}
- name: radio_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '106200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: varaible_delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    start: '0'
    step: '1'
    stop: '10'
    value: '3'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '90000'
    audio_stop: '94000'
    chan_rate: samp_rate
    comment: FM demodulation without de-emphasis
    deviation: '75000'
    gain: '1.0'
    tau: '0'
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    comment: 19 kHz pilot tone
    max_freq: pll_max_freq
    min_freq: pll_min_freq
    w: '0.0002'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: Stereo radio signal out
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '21000'
    low_cutoff_freq: '17000'
    samp_rate: if_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    comment: |-
      38 kHz carrier in same
      phase as the pilot tone
    decim: '1'
    gain: '2'
    high_cutoff_freq: '41000'
    low_cutoff_freq: '35000'
    samp_rate: if_samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: varaible_delay
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    comment: 38 kHz positive peak
    look_ahead: '3'
    threshold_factor_fall: '0.40'
    threshold_factor_rise: '0.25'
    type: float
  states: {}
- name: blocks_peak_detector_xb_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    comment: 38 kHz negative peak
    look_ahead: '3'
    threshold_factor_fall: '0.40'
    threshold_factor_rise: '0.25'
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: if_samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: if_samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: if_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    label1: Demodulated FM
    label2: PLL output
    label3: ''
    nconnections: '3'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    nconnections: '2'
    size: '2048'
    srate: '48000'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '3'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: radio_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', low_pass_filter_0_0_0, '0']
- [analog_fm_deemph_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', analog_pll_refout_cc_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0_0, '2']
- [blocks_delay_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_peak_detector_xb_0_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_peak_detector_xb_0, '0', blocks_sample_and_hold_xx_0, '1']
- [blocks_peak_detector_xb_0_0, '0', blocks_sample_and_hold_xx_0_0, '1']
- [blocks_sample_and_hold_xx_0, '0', analog_fm_deemph_0, '0']
- [blocks_sample_and_hold_xx_0_0, '0', analog_fm_deemph_0_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', blocks_sample_and_hold_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_sample_and_hold_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', audio_sink_0_0, '1']
- [rational_resampler_xxx_0_0_0_0, '0', blocks_float_to_complex_1, '0']
- [rational_resampler_xxx_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
